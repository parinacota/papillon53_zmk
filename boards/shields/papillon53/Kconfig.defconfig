## boards/shields/papillon53/Kconfig.defconfig
```kconfig
if SHIELD_PAPILLON53

config ZMK_KEYBOARD_NAME
    default "papillon53"

config ZMK_BLE
	default y

config ZMK_USB
	default y

endif
```
